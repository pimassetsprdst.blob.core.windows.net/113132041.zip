Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T15:40:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 15:40:33 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\f522b131-111b-4b1d-8e1b-e3cc9365ec30\ifc * Database version: 5507 * Database creation date: Mon Oct 24 15:40:32 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 15:40:32 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 15:40:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort, Port_3173937
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA001012A1085, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN:2CKA001012A1085:3173942
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; EMCS Version: 4.0; ETIM Article Class: EC001590; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395007303; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001012A1085; Manufacturer Type: 2000/5 US; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001012A1085,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA001012A1085; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA001012A1085
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA001012A1085
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN: 2CKA001012A1085; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN: 2CKA001012A1085; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN: 2CKA001012A1085; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001012A1085_DE-EN: 2CKA001012A1085
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: future linear_2CKA001754A4235_hor_1, E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN:future linear_2CKA001754A4235_hor_1:3173937
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 7 mm; Gang Height: 64 mm; Gang Width: 64 mm; Height: 80 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 0 mm; Width: 80 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Studio white; Material: Color RAL 9016; Number of Gangs: 1
Type - Identity Data - Article Code: Default; Article Description: Future linear Cover frame, studio white, future linear cover frame; Article Type: 1-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Future linear Cover frame, studio white, future linear cover frame; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395050750; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001754A4235; Manufacturer Type: 1721-184K; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001754A4235,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 1-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: future linear; Revit Version: 2020; Type Name: future linear_2CKA001754A4235_hor_1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_2CKA001754A4235_hor_1
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: future linear_2CKA001754A4235_hor_1
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0113706 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000026344 m3
Electrical - Loads - Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Family: E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4235_hor_1; Family and Type: E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4235_hor_1; Gang 3: 0 mm; Gang Reference Line: 64 mm; Interior Width: 32 mm; Number of Representation Line: 2; Type: E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4235_hor_1; Type Id: E_Frame_Switch Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_DE-EN: future linear_2CKA001754A4235_hor_1
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: future linear_1 Pole_2CKA001751A2752, E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN:future linear_1 Pole_2CKA001751A2752:3173941
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9016
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 63 mm; Rounding Radius: 1 mm; Width: 63 mm
Type - Electrical - Material: Color RAL 9016; App ID: EL_MODELPARTSYSTEM; Insert Type: Studio white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Rocker, studio white, Covers for switches/push-buttons; Base Family Version: 20221003; Category: EL_DOUBLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Rocker, studio white, Covers for switches/push-buttons; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395995914; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001751A2752; Manufacturer Type: 1785-84; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001751A2752,artikel.html; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: future linear; Revit Version: 2020; Type Name: future linear_1 Pole_2CKA001751A2752; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: future linear_1 Pole_2CKA001751A2752
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: future linear_1 Pole_2CKA001751A2752
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 3; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00997388 m2; Volume: 0.0000555402 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchSeriesOnePole: yes; Family: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN: future linear_1 Pole_2CKA001751A2752; Family and Type: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN: future linear_1 Pole_2CKA001751A2752; Type: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN: future linear_1 Pole_2CKA001751A2752; Type Id: E_Switch_Series_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_future linear_2CKA001751A2752_DE-EN: future linear_1 Pole_2CKA001751A2752
Phasing - Phase Created: 4. Plan over 10 years
